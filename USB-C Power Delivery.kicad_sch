File: USB-C Power Delivery.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Fixed 5V Line
